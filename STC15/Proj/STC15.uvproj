# Keil uVision project STC15.uvproj, settings and files
target STC15 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Peripheral;..\User;..\User\OLED;..\User\DS18B20
  group User
    ../User/: main.c
    ../User/OLED/: oled.c
    ../User/DS18B20/: ds18b20.c
  group Peripheral
    ../Peripheral/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C PWM.c
